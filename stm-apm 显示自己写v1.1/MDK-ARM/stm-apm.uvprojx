# Keil uVision project stm-apm.uvprojx, settings and files
target stm-apm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F030CC Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm-apm +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Drivers/GUI/lvgl/src/lv_core;../Drivers/GUI/lvgl/src/lv_draw;../Drivers/GUI/lvgl/src/lv_font;../Drivers/GUI/lvgl/src/lv_hal;../Drivers/GUI/lvgl/src/lv_misc;../Drivers/GUI/lvgl/src/lv_objx;../Drivers/GUI/lvgl/src/lv_themes;../Drivers/GUI;../Drivers/GUI/lv_examples;../Drivers/GUI/lvgl;../Drivers/GUI/lvgl_driver;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Drivers\STM32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f030xc.s
  group Application/User/Core
    ../Core/Src/: LCD.c display_ziku.c main.c gpio.c adc.c dma.c rtc.c tim.c stm32f0xx_it.c stm32f0xx_hal_msp.c Menu.c tool.c usart.c
    ../Core/Inc/: Menu.h tool.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
    ../Drivers/STM32F0xx_HAL_Driver/Inc/: stm32f0xx_hal_uart.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group GUI
    ../Drivers/GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Drivers/GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Drivers/GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../Drivers/GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Drivers/GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Drivers/GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ../Drivers/GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
    ../Drivers/GUI/: lv_conf.h
  group GUI_APP
    ../Drivers/GUI_APP/: Chinese_16.c
software components: CMSIS:CORE 5.4.0
